HEC-RAS study MTGHP_Steady.prj: MTGHP_Steady

--- MTGHP_Steady.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,510.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616089.373222  3097131.820233   616083.778403  3097132.061051
#Sta/Elev= 6
   0.000 640.013   0.200 640.013   0.200 632.125   5.400 632.125   5.400 640.013
   5.600 640.013
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,515.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616089.584332  3097136.818692   616083.989264  3097137.053684
#Sta/Elev= 6
   0.000 640.015   0.200 640.015   0.200 632.128   5.400 632.128   5.400 640.015
   5.600 640.015
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,520.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616089.795349  3097141.814119   616084.200292  3097142.049346
#Sta/Elev= 6
   0.000 640.018   0.200 640.018   0.200 632.130   5.400 632.130   5.400 640.018
   5.600 640.018
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,525.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616090.007205  3097146.806828   616084.412385  3097147.047646
#Sta/Elev= 6
   0.000 640.020   0.200 640.020   0.200 632.133   5.400 632.133   5.400 640.020
   5.600 640.020
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,530.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616090.218351  3097151.805167   616084.623294  3097152.040395
#Sta/Elev= 6
   0.000 640.023   0.200 640.023   0.200 632.135   5.400 632.135   5.400 640.023
   5.600 640.023
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,535.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616090.429332  3097156.800713   616084.834275  3097157.035941
#Sta/Elev= 6
   0.000 640.025   0.200 640.025   0.200 632.138   5.400 632.138   5.400 640.025
   5.600 640.025
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,540.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616090.640355  3097161.796258   616085.045298  3097162.031486
#Sta/Elev= 6
   0.000 640.028   0.200 640.028   0.200 632.140   5.400 632.140   5.400 640.028
   5.600 640.028
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,545.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616090.852211  3097166.788967   616085.257391  3097167.029785
#Sta/Elev= 6
   0.000 640.030   0.200 640.030   0.200 632.143   5.400 632.143   5.400 640.030
   5.600 640.030
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,550.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616091.063357  3097171.787306   616085.468300  3097172.022534
#Sta/Elev= 6
   0.000 640.033   0.200 640.033   0.200 632.145   5.400 632.145   5.400 640.033
   5.600 640.033
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,555.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616091.274338  3097176.782853   616085.679281  3097177.018080
#Sta/Elev= 6
   0.000 640.035   0.200 640.035   0.200 632.148   5.400 632.148   5.400 640.035
   5.600 640.035
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,560.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616091.486236  3097181.775560   616085.891417  3097182.016378
#Sta/Elev= 6
   0.000 640.038   0.200 640.038   0.200 632.150   5.400 632.150   5.400 640.038
   5.600 640.038
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,565.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616091.697340  3097186.773901   616086.102283  3097187.009129
#Sta/Elev= 6
   0.000 640.040   0.200 640.040   0.200 632.153   5.400 632.153   5.400 640.040
   5.600 640.040
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,570.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616091.908363  3097191.769446   616086.313306  3097192.004673
#Sta/Elev= 6
   0.000 640.043   0.200 640.043   0.200 632.155   5.400 632.155   5.400 640.043
   5.600 640.043
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,575.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616092.119344  3097196.764992   616086.524287  3097197.000220
#Sta/Elev= 6
   0.000 640.045   0.200 640.045   0.200 632.158   5.400 632.158   5.400 640.045
   5.600 640.045
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,580.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616092.331365  3097201.760494   616086.736308  3097201.995722
#Sta/Elev= 6
   0.000 640.047   0.200 640.047   0.200 632.160   5.400 632.160   5.400 640.047
   5.600 640.047
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,585.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616092.542346  3097206.756040   616086.947289  3097206.991268
#Sta/Elev= 6
   0.000 640.050   0.200 640.050   0.200 632.162   5.400 632.162   5.400 640.050
   5.600 640.050
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,590.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616092.753332  3097211.751704   616087.158265  3097211.986697
#Sta/Elev= 6
   0.000 640.052   0.200 640.052   0.200 632.165   5.400 632.165   5.400 640.052
   5.600 640.052
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,595.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616092.965225  3097216.744294   616087.370405  3097216.985112
#Sta/Elev= 6
   0.000 640.055   0.200 640.055   0.200 632.167   5.400 632.167   5.400 640.055
   5.600 640.055
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,600.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616093.176329  3097221.742635   616087.581272  3097221.977863
#Sta/Elev= 6
   0.000 640.057   0.200 640.057   0.200 632.170   5.400 632.170   5.400 640.057
   5.600 640.057
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,605.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616093.387352  3097226.738180   616087.792294  3097226.973407
#Sta/Elev= 6
   0.000 640.060   0.200 640.060   0.200 632.172   5.400 632.172   5.400 640.060
   5.600 640.060
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,610.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616093.599207  3097231.730888   616088.004388  3097231.971707
#Sta/Elev= 6
   0.000 640.062   0.200 640.062   0.200 632.175   5.400 632.175   5.400 640.062
   5.600 640.062
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,615.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616093.810354  3097236.729228   616088.215296  3097236.964456
#Sta/Elev= 6
   0.000 640.065   0.200 640.065   0.200 632.177   5.400 632.177   5.400 640.065
   5.600 640.065
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,620.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616094.021335  3097241.724774   616088.426277  3097241.960002
#Sta/Elev= 6
   0.000 640.067   0.200 640.067   0.200 632.180   5.400 632.180   5.400 640.067
   5.600 640.067
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,625.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616094.237565  3097246.703285   616088.644018  3097246.972044
#Sta/Elev= 6
   0.000 640.070   0.200 640.070   0.200 632.182   5.400 632.182   5.400 640.070
   5.600 640.070
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,630.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616094.547166  3097251.557297   616089.105910  3097252.087218
#Sta/Elev= 6
   0.000 640.069   0.200 640.069   0.200 632.185   5.267 632.185   5.267 640.069
   5.467 640.069
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.267   0.015   0.000
Bank Sta=0.200,5.267
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,635.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616095.165156  3097256.379809   616089.757445  3097257.182772
#Sta/Elev= 6
   0.000 640.071   0.200 640.071   0.200 632.187   5.267 632.187   5.267 640.071
   5.467 640.071
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.267   0.015   0.000
Bank Sta=0.200,5.267
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,640.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616096.023607  3097261.166861   616090.662562  3097262.237977
#Sta/Elev= 6
   0.000 640.074   0.200 640.074   0.200 632.190   5.267 632.190   5.267 640.074
   5.467 640.074
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.267   0.015   0.000
Bank Sta=0.200,5.267
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,645.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616097.120157  3097265.903200   616091.819946  3097267.243294
#Sta/Elev= 6
   0.000 640.076   0.200 640.076   0.200 632.192   5.267 632.192   5.267 640.076
   5.467 640.076
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.267   0.015   0.000
Bank Sta=0.200,5.267
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,650.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616098.452210  3097270.580767   616093.225196  3097272.182770
#Sta/Elev= 6
   0.000 640.079   0.200 640.079   0.200 632.195   5.267 632.195   5.267 640.079
   5.467 640.079
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.267   0.015   0.000
Bank Sta=0.200,5.267
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,655.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616100.017285  3097275.186824   616094.875616  3097277.044601
#Sta/Elev= 6
   0.000 640.081   0.200 640.081   0.200 632.197   5.267 632.197   5.267 640.081
   5.467 640.081
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.267   0.015   0.000
Bank Sta=0.200,5.267
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,660.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616101.808995  3097279.705538   616096.768050  3097281.821423
#Sta/Elev= 6
   0.000 640.084   0.200 640.084   0.200 632.200   5.267 632.200   5.267 640.084
   5.467 640.084
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.267   0.015   0.000
Bank Sta=0.200,5.267
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,665.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616103.825145  3097284.131692   616098.895494  3097286.495298
#Sta/Elev= 6
   0.000 640.086   0.200 640.086   0.200 632.202   5.267 632.202   5.267 640.086
   5.467 640.086
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.267   0.015   0.000
Bank Sta=0.200,5.267
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,670.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616106.060843  3097288.459474   616101.247659  3097291.052030
#Sta/Elev= 6
   0.000 640.089   0.200 640.089   0.200 632.205   5.267 632.205   5.267 640.089
   5.467 640.089
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.267   0.015   0.000
Bank Sta=0.200,5.267
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,675.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616108.490027  3097292.827419   616103.562089  3097295.487386
#Sta/Elev= 6
   0.000 640.099   0.200 640.099   0.200 632.207   5.400 632.207   5.400 640.099
   5.600 640.099
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,680.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616110.861063  3097297.229485   616105.933124  3097299.889452
#Sta/Elev= 6
   0.000 640.101   0.200 640.101   0.200 632.210   5.400 632.210   5.400 640.101
   5.600 640.101
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,685.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616113.233271  3097301.633719   616108.302993  3097304.289346
#Sta/Elev= 6
   0.000 640.104   0.200 640.104   0.200 632.212   5.400 632.212   5.400 640.104
   5.600 640.104
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,690.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616115.604307  3097306.035785   616110.674029  3097308.691412
#Sta/Elev= 6
   0.000 640.106   0.200 640.106   0.200 632.215   5.400 632.215   5.400 640.106
   5.600 640.106
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,695.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616117.975343  3097310.437852   616113.045065  3097313.093479
#Sta/Elev= 6
   0.000 640.109   0.200 640.109   0.200 632.217   5.400 632.217   5.400 640.109
   5.600 640.109
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,700.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616120.346378  3097314.839917   616115.416100  3097317.495545
#Sta/Elev= 6
   0.000 640.111   0.200 640.111   0.200 632.220   5.400 632.220   5.400 640.111
   5.600 640.111
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,705.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616122.717016  3097319.239398   616117.789077  3097321.899365
#Sta/Elev= 6
   0.000 640.114   0.200 640.114   0.200 632.222   5.400 632.222   5.400 640.114
   5.600 640.114
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,710.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616125.088051  3097323.641464   616120.160113  3097326.301430
#Sta/Elev= 6
   0.000 640.116   0.200 640.116   0.200 632.225   5.400 632.225   5.400 640.116
   5.600 640.116
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,715.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616127.460260  3097328.045698   616122.529982  3097330.701325
#Sta/Elev= 6
   0.000 640.119   0.200 640.119   0.200 632.227   5.400 632.227   5.400 640.119
   5.600 640.119
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,720.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616129.831296  3097332.447764   616124.901017  3097335.103391
#Sta/Elev= 6
   0.000 640.121   0.200 640.121   0.200 632.230   5.400 632.230   5.400 640.121
   5.600 640.121
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,725.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616132.202331  3097336.849830   616127.272053  3097339.505458
#Sta/Elev= 6
   0.000 640.124   0.200 640.124   0.200 632.232   5.400 632.232   5.400 640.124
   5.600 640.124
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,730.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616134.573367  3097341.251896   616129.643089  3097343.907523
#Sta/Elev= 6
   0.000 640.126   0.200 640.126   0.200 632.235   5.400 632.235   5.400 640.126
   5.600 640.126
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,735.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616136.944403  3097345.653963   616132.014124  3097348.309590
#Sta/Elev= 6
   0.000 640.129   0.200 640.129   0.200 632.237   5.400 632.237   5.400 640.129
   5.600 640.129
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,740.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616139.315040  3097350.053443   616134.387102  3097352.713410
#Sta/Elev= 6
   0.000 640.131   0.200 640.131   0.200 632.240   5.400 632.240   5.400 640.131
   5.600 640.131
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,745.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616141.687249  3097354.457677   616136.756971  3097357.113304
#Sta/Elev= 6
   0.000 640.134   0.200 640.134   0.200 632.242   5.400 632.242   5.400 640.134
   5.600 640.134
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,750.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616144.058284  3097358.859743   616139.128006  3097361.515370
#Sta/Elev= 6
   0.000 640.136   0.200 640.136   0.200 632.245   5.400 632.245   5.400 640.136
   5.600 640.136
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,755.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616146.429320  3097363.261809   616141.499042  3097365.917436
#Sta/Elev= 6
   0.000 640.139   0.200 640.139   0.200 632.247   5.400 632.247   5.400 640.139
   5.600 640.139
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,760.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616148.800356  3097367.663875   616143.870077  3097370.319502
#Sta/Elev= 6
   0.000 640.141   0.200 640.141   0.200 632.250   5.400 632.250   5.400 640.141
   5.600 640.141
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,765.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616151.171391  3097372.065941   616146.241113  3097374.721568
#Sta/Elev= 6
   0.000 640.144   0.200 640.144   0.200 632.252   5.400 632.252   5.400 640.144
   5.600 640.144
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,770.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616153.542029  3097376.465421   616148.614090  3097379.125388
#Sta/Elev= 6
   0.000 640.146   0.200 640.146   0.200 632.255   5.400 632.255   5.400 640.146
   5.600 640.146
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,775.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616155.913064  3097380.867487   616150.985126  3097383.527454
#Sta/Elev= 6
   0.000 640.149   0.200 640.149   0.200 632.257   5.400 632.257   5.400 640.149
   5.600 640.149
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,780.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616158.285273  3097385.271721   616153.354994  3097387.927349
#Sta/Elev= 6
   0.000 640.151   0.200 640.151   0.200 632.260   5.400 632.260   5.400 640.151
   5.600 640.151
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,785.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616160.656308  3097389.673788   616155.726030  3097392.329415
#Sta/Elev= 6
   0.000 640.154   0.200 640.154   0.200 632.262   5.400 632.262   5.400 640.154
   5.600 640.154
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,790.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616163.027344  3097394.075854   616158.097066  3097396.731481
#Sta/Elev= 6
   0.000 640.156   0.200 640.156   0.200 632.265   5.400 632.265   5.400 640.156
   5.600 640.156
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,795.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616165.398380  3097398.477920   616160.468101  3097401.133547
#Sta/Elev= 6
   0.000 640.159   0.200 640.159   0.200 632.267   5.400 632.267   5.400 640.159
   5.600 640.159
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,800.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616167.769415  3097402.879986   616162.839137  3097405.535613
#Sta/Elev= 6
   0.000 640.161   0.200 640.161   0.200 632.270   5.400 632.270   5.400 640.161
   5.600 640.161
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,805.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616170.140053  3097407.279467   616165.212115  3097409.939433
#Sta/Elev= 6
   0.000 640.164   0.200 640.164   0.200 632.272   5.400 632.272   5.400 640.164
   5.600 640.164
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,810.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616172.512262  3097411.683701   616167.581983  3097414.339328
#Sta/Elev= 6
   0.000 640.166   0.200 640.166   0.200 632.275   5.400 632.275   5.400 640.166
   5.600 640.166
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,815.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616174.883297  3097416.085767   616169.953019  3097418.741394
#Sta/Elev= 6
   0.000 640.169   0.200 640.169   0.200 632.277   5.400 632.277   5.400 640.169
   5.600 640.169
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,820.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616177.254333  3097420.487833   616172.324054  3097423.143460
#Sta/Elev= 6
   0.000 640.171   0.200 640.171   0.200 632.280   5.400 632.280   5.400 640.171
   5.600 640.171
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,825.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616179.625368  3097424.889899   616174.695090  3097427.545526
#Sta/Elev= 6
   0.000 640.174   0.200 640.174   0.200 632.282   5.400 632.282   5.400 640.174
   5.600 640.174
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,830.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616181.996404  3097429.291965   616177.066126  3097431.947592
#Sta/Elev= 6
   0.000 640.176   0.200 640.176   0.200 632.285   5.400 632.285   5.400 640.176
   5.600 640.176
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,835.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616184.367041  3097433.691445   616179.439103  3097436.351412
#Sta/Elev= 6
   0.000 640.179   0.200 640.179   0.200 632.287   5.400 632.287   5.400 640.179
   5.600 640.179
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,840.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616186.738077  3097438.093511   616181.810139  3097440.753478
#Sta/Elev= 6
   0.000 640.181   0.200 640.181   0.200 632.290   5.400 632.290   5.400 640.181
   5.600 640.181
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,845.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616189.110286  3097442.497745   616184.180007  3097445.153372
#Sta/Elev= 6
   0.000 640.184   0.200 640.184   0.200 632.292   5.400 632.292   5.400 640.184
   5.600 640.184
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,850.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616191.481321  3097446.899811   616186.551043  3097449.555439
#Sta/Elev= 6
   0.000 640.186   0.200 640.186   0.200 632.295   5.400 632.295   5.400 640.186
   5.600 640.186
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,855.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616193.852357  3097451.301878   616188.922079  3097453.957505
#Sta/Elev= 6
   0.000 640.189   0.200 640.189   0.200 632.297   5.400 632.297   5.400 640.189
   5.600 640.189
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,860.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616196.223392  3097455.703944   616191.293114  3097458.359571
#Sta/Elev= 6
   0.000 640.191   0.200 640.191   0.200 632.300   5.400 632.300   5.400 640.191
   5.600 640.191
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,865.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616198.594428  3097460.106010   616193.664150  3097462.761637
#Sta/Elev= 6
   0.000 640.194   0.200 640.194   0.200 632.302   5.400 632.302   5.400 640.194
   5.600 640.194
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,870.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616200.965066  3097464.505490   616196.037127  3097467.165457
#Sta/Elev= 6
   0.000 640.196   0.200 640.196   0.200 632.305   5.400 632.305   5.400 640.196
   5.600 640.196
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,875.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616203.337274  3097468.909724   616198.406996  3097471.565351
#Sta/Elev= 6
   0.000 640.199   0.200 640.199   0.200 632.307   5.400 632.307   5.400 640.199
   5.600 640.199
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,880.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616205.708310  3097473.311790   616200.778032  3097475.967417
#Sta/Elev= 6
   0.000 640.201   0.200 640.201   0.200 632.310   5.400 632.310   5.400 640.201
   5.600 640.201
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,885.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616208.079346  3097477.713856   616203.149067  3097480.369484
#Sta/Elev= 6
   0.000 640.204   0.200 640.204   0.200 632.312   5.400 632.312   5.400 640.204
   5.600 640.204
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,890.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616210.450381  3097482.115922   616205.520103  3097484.771550
#Sta/Elev= 6
   0.000 640.206   0.200 640.206   0.200 632.315   5.400 632.315   5.400 640.206
   5.600 640.206
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,895.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616212.821417  3097486.517988   616207.891138  3097489.173616
#Sta/Elev= 6
   0.000 640.209   0.200 640.209   0.200 632.317   5.400 632.317   5.400 640.209
   5.600 640.209
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,900.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616215.192054  3097490.917469   616210.264116  3097493.577435
#Sta/Elev= 6
   0.000 640.211   0.200 640.211   0.200 632.320   5.400 632.320   5.400 640.211
   5.600 640.211
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,905.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616217.563090  3097495.319535   616212.635151  3097497.979501
#Sta/Elev= 6
   0.000 640.214   0.200 640.214   0.200 632.322   5.400 632.322   5.400 640.214
   5.600 640.214
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,910.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616219.935298  3097499.723769   616215.005020  3097502.379396
#Sta/Elev= 6
   0.000 640.216   0.200 640.216   0.200 632.325   5.400 632.325   5.400 640.216
   5.600 640.216
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,915.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616222.306334  3097504.125835   616217.376056  3097506.781462
#Sta/Elev= 6
   0.000 640.219   0.200 640.219   0.200 632.327   5.400 632.327   5.400 640.219
   5.600 640.219
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,920.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616224.677583  3097508.529294   616219.746047  3097511.182584
#Sta/Elev= 6
   0.000 640.221   0.200 640.221   0.200 632.330   5.400 632.330   5.400 640.221
   5.600 640.221
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,925.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616227.048619  3097512.931360   616222.117082  3097515.584649
#Sta/Elev= 6
   0.000 640.224   0.200 640.224   0.200 632.332   5.400 632.332   5.400 640.224
   5.600 640.224
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,930.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616229.419654  3097517.333426   616224.488118  3097519.986715
#Sta/Elev= 6
   0.000 640.226   0.200 640.226   0.200 632.335   5.400 632.335   5.400 640.226
   5.600 640.226
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,935.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616231.790293  3097521.732907   616226.861093  3097524.390535
#Sta/Elev= 6
   0.000 640.229   0.200 640.229   0.200 632.337   5.400 632.337   5.400 640.229
   5.600 640.229
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,940.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616234.162500  3097526.137140   616229.230964  3097528.790430
#Sta/Elev= 6
   0.000 640.231   0.200 640.231   0.200 632.340   5.400 632.340   5.400 640.231
   5.600 640.231
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,945.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616236.533536  3097530.539206   616231.601999  3097533.192496
#Sta/Elev= 6
   0.000 640.234   0.200 640.234   0.200 632.342   5.400 632.342   5.400 640.234
   5.600 640.234
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,950.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616238.904572  3097534.941272   616233.973035  3097537.594562
#Sta/Elev= 6
   0.000 640.236   0.200 640.236   0.200 632.345   5.400 632.345   5.400 640.236
   5.600 640.236
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,955.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616241.275607  3097539.343338   616236.344070  3097541.996628
#Sta/Elev= 6
   0.000 640.239   0.200 640.239   0.200 632.347   5.400 632.347   5.400 640.239
   5.600 640.239
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,960.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616243.646643  3097543.745404   616238.715106  3097546.398694
#Sta/Elev= 6
   0.000 640.241   0.200 640.241   0.200 632.350   5.400 632.350   5.400 640.241
   5.600 640.241
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,965.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616246.017281  3097548.144885   616241.088081  3097550.802513
#Sta/Elev= 6
   0.000 640.244   0.200 640.244   0.200 632.352   5.400 632.352   5.400 640.244
   5.600 640.244
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,970.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616248.388317  3097552.546952   616243.459117  3097555.204580
#Sta/Elev= 6
   0.000 640.246   0.200 640.246   0.200 632.355   5.400 632.355   5.400 640.246
   5.600 640.246
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,975.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616250.760525  3097556.951185   616245.828988  3097559.604475
#Sta/Elev= 6
   0.000 640.249   0.200 640.249   0.200 632.357   5.400 632.357   5.400 640.249
   5.600 640.249
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,980.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616253.131560  3097561.353251   616248.200024  3097564.006541
#Sta/Elev= 6
   0.000 640.251   0.200 640.251   0.200 632.360   5.400 632.360   5.400 640.251
   5.600 640.251
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,985.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616255.502596  3097565.755317   616250.571059  3097568.408607
#Sta/Elev= 6
   0.000 640.254   0.200 640.254   0.200 632.362   5.400 632.362   5.400 640.254
   5.600 640.254
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,990.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616257.873631  3097570.157383   616252.942095  3097572.810673
#Sta/Elev= 6
   0.000 640.256   0.200 640.256   0.200 632.365   5.400 632.365   5.400 640.256
   5.600 640.256
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,995.515 ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616260.244270  3097574.556865   616255.315070  3097577.214493
#Sta/Elev= 6
   0.000 640.259   0.200 640.259   0.200 632.367   5.400 632.367   5.400 640.259
   5.600 640.259
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1000.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616262.615306  3097578.958931   616257.686106  3097581.616559
#Sta/Elev= 6
   0.000 640.261   0.200 640.261   0.200 632.370   5.400 632.370   5.400 640.261
   5.600 640.261
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1005.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616264.987513  3097583.363164   616260.055977  3097586.016454
#Sta/Elev= 6
   0.000 640.264   0.200 640.264   0.200 632.372   5.400 632.372   5.400 640.264
   5.600 640.264
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1010.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616267.358549  3097587.765230   616262.427012  3097590.418520
#Sta/Elev= 6
   0.000 640.266   0.200 640.266   0.200 632.375   5.400 632.375   5.400 640.266
   5.600 640.266
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1015.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616269.729585  3097592.167297   616264.798048  3097594.820586
#Sta/Elev= 6
   0.000 640.269   0.200 640.269   0.200 632.377   5.400 632.377   5.400 640.269
   5.600 640.269
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1020.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616272.100620  3097596.569362   616267.169084  3097599.222652
#Sta/Elev= 6
   0.000 640.271   0.200 640.271   0.200 632.380   5.400 632.380   5.400 640.271
   5.600 640.271
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1025.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616274.471656  3097600.971428   616269.540119  3097603.624718
#Sta/Elev= 6
   0.000 640.274   0.200 640.274   0.200 632.382   5.400 632.382   5.400 640.274
   5.600 640.274
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1030.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616276.842295  3097605.370910   616271.913094  3097608.028538
#Sta/Elev= 6
   0.000 640.276   0.200 640.276   0.200 632.385   5.400 632.385   5.400 640.276
   5.600 640.276
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1035.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616279.214502  3097609.775143   616274.282965  3097612.428433
#Sta/Elev= 6
   0.000 640.279   0.200 640.279   0.200 632.387   5.400 632.387   5.400 640.279
   5.600 640.279
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1040.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616281.585537  3097614.177209   616276.654001  3097616.830499
#Sta/Elev= 6
   0.000 640.281   0.200 640.281   0.200 632.390   5.400 632.390   5.400 640.281
   5.600 640.281
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1045.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616283.956573  3097618.579275   616279.025037  3097621.232565
#Sta/Elev= 6
   0.000 640.284   0.200 640.284   0.200 632.392   5.400 632.392   5.400 640.284
   5.600 640.284
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1050.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616286.327609  3097622.981341   616281.396072  3097625.634631
#Sta/Elev= 6
   0.000 640.286   0.200 640.286   0.200 632.395   5.400 632.395   5.400 640.286
   5.600 640.286
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1055.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616288.698644  3097627.383407   616283.767107  3097630.036697
#Sta/Elev= 6
   0.000 640.289   0.200 640.289   0.200 632.397   5.400 632.397   5.400 640.289
   5.600 640.289
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1060.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616291.069283  3097631.782888   616286.140083  3097634.440516
#Sta/Elev= 6
   0.000 640.291   0.200 640.291   0.200 632.400   5.400 632.400   5.400 640.291
   5.600 640.291
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1065.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616293.440319  3097636.184955   616288.511118  3097638.842582
#Sta/Elev= 6
   0.000 640.294   0.200 640.294   0.200 632.402   5.400 632.402   5.400 640.294
   5.600 640.294
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1070.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616295.812526  3097640.589188   616290.880989  3097643.242477
#Sta/Elev= 6
   0.000 640.296   0.200 640.296   0.200 632.405   5.400 632.405   5.400 640.296
   5.600 640.296
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1075.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616298.183562  3097644.991254   616293.252025  3097647.644544
#Sta/Elev= 6
   0.000 640.299   0.200 640.299   0.200 632.407   5.400 632.407   5.400 640.299
   5.600 640.299
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1080.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616300.554597  3097649.393320   616295.623061  3097652.046610
#Sta/Elev= 6
   0.000 640.301   0.200 640.301   0.200 632.410   5.400 632.410   5.400 640.301
   5.600 640.301
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1085.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616302.925633  3097653.795386   616297.994096  3097656.448676
#Sta/Elev= 6
   0.000 640.304   0.200 640.304   0.200 632.412   5.400 632.412   5.400 640.304
   5.600 640.304
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1090.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616305.296668  3097658.197452   616300.365132  3097660.850742
#Sta/Elev= 6
   0.000 640.306   0.200 640.306   0.200 632.415   5.400 632.415   5.400 640.306
   5.600 640.306
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1095.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616307.667307  3097662.596933   616302.738107  3097665.254561
#Sta/Elev= 6
   0.000 640.309   0.200 640.309   0.200 632.417   5.400 632.417   5.400 640.309
   5.600 640.309
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1100.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616310.039301  3097666.999774   616305.109023  3097669.655401
#Sta/Elev= 6
   0.000 640.311   0.200 640.311   0.200 632.419   5.400 632.419   5.400 640.311
   5.600 640.311
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1105.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616312.251178  3097671.143994   616308.216443  3097673.971757
#Sta/Elev= 6
   0.000 640.282   0.200 640.282   0.200 632.422   4.727 632.422   4.727 640.282
   4.927 640.282
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.727   0.015   0.000
Bank Sta=0.200,4.727
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1110.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616315.225349  3097674.768323   616311.575655  3097678.078167
#Sta/Elev= 6
   0.000 640.285   0.200 640.285   0.200 632.424   4.727 632.424   4.727 640.285
   4.927 640.285
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.727   0.015   0.000
Bank Sta=0.200,4.727
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1115.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616318.629049  3097677.995559   616315.418546  3097681.732939
#Sta/Elev= 6
   0.000 640.287   0.200 640.287   0.200 632.427   4.727 632.427   4.727 640.287
   4.927 640.287
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.727   0.015   0.000
Bank Sta=0.200,4.727
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1120.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616322.407901  3097680.771872   616319.688550  3097684.880456
#Sta/Elev= 6
   0.000 640.290   0.200 640.290   0.200 632.429   4.727 632.429   4.727 640.290
   4.927 640.290
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.727   0.015   0.000
Bank Sta=0.200,4.727
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1125.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616326.503316  3097683.055421   616324.317634  3097687.471089
#Sta/Elev= 6
   0.000 640.292   0.200 640.292   0.200 632.432   4.727 632.432   4.727 640.292
   4.927 640.292
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.727   0.015   0.000
Bank Sta=0.200,4.727
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1130.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616330.852406  3097684.811221   616329.232448  3097689.464291
#Sta/Elev= 6
   0.000 640.295   0.200 640.295   0.200 632.434   4.727 632.434   4.727 640.295
   4.927 640.295
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.727   0.015   0.000
Bank Sta=0.200,4.727
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1135.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616335.384623  3097686.009787   616334.359678  3097690.829001
#Sta/Elev= 6
   0.000 640.297   0.200 640.297   0.200 632.437   4.727 632.437   4.727 640.297
   4.927 640.297
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.727   0.015   0.000
Bank Sta=0.200,4.727
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
