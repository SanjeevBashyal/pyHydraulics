HEC-RAS study MTGHP_Steady.prj: MTGHP_Steady

--- MTGHP_Steady.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,1140.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616340.030879  3097686.634949   616339.616819  3097691.544520
#Sta/Elev= 6
   0.000 640.300   0.200 640.300   0.200 632.439   4.727 632.439   4.727 640.300
   4.927 640.300
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.727   0.015   0.000
Bank Sta=0.200,4.727
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1145.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616344.951916  3097686.543060   616344.683157  3097692.136607
#Sta/Elev= 6
   0.000 640.354   0.200 640.354   0.200 632.442   5.400 632.442   5.400 640.354
   5.600 640.354
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1150.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616349.946247  3097686.781076   616349.677488  3097692.374623
#Sta/Elev= 6
   0.000 640.356   0.200 640.356   0.200 632.444   5.400 632.444   5.400 640.356
   5.600 640.356
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1155.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616354.940578  3097687.019092   616354.671819  3097692.612639
#Sta/Elev= 6
   0.000 640.359   0.200 640.359   0.200 632.447   5.400 632.447   5.400 640.359
   5.600 640.359
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1160.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616359.934912  3097687.257060   616359.666153  3097692.850607
#Sta/Elev= 6
   0.000 640.361   0.200 640.361   0.200 632.449   5.400 632.449   5.400 640.361
   5.600 640.361
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1165.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616364.926449  3097687.494946   616364.663277  3097693.088759
#Sta/Elev= 6
   0.000 640.364   0.200 640.364   0.200 632.452   5.400 632.452   5.400 640.364
   5.600 640.364
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1170.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616369.920780  3097687.732962   616369.657608  3097693.326774
#Sta/Elev= 6
   0.000 640.366   0.200 640.366   0.200 632.454   5.400 632.454   5.400 640.366
   5.600 640.366
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1175.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616374.915114  3097687.970930   616374.651941  3097693.564743
#Sta/Elev= 6
   0.000 640.369   0.200 640.369   0.200 632.457   5.400 632.457   5.400 640.369
   5.600 640.369
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1180.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616379.909445  3097688.208946   616379.646272  3097693.802759
#Sta/Elev= 6
   0.000 640.371   0.200 640.371   0.200 632.459   5.400 632.459   5.400 640.371
   5.600 640.371
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1185.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616384.906522  3097688.448089   616384.637763  3097694.041636
#Sta/Elev= 6
   0.000 640.374   0.200 640.374   0.200 632.462   5.400 632.462   5.400 640.374
   5.600 640.374
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1190.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616389.900855  3097688.686057   616389.632096  3097694.279604
#Sta/Elev= 6
   0.000 640.376   0.200 640.376   0.200 632.464   5.400 632.464   5.400 640.376
   5.600 640.376
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1195.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616394.895186  3097688.924073   616394.626427  3097694.517620
#Sta/Elev= 6
   0.000 640.379   0.200 640.379   0.200 632.467   5.400 632.467   5.400 640.379
   5.600 640.379
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1200.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616399.889517  3097689.162089   616399.620758  3097694.755636
#Sta/Elev= 6
   0.000 640.381   0.200 640.381   0.200 632.469   5.400 632.469   5.400 640.381
   5.600 640.381
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1205.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616404.883850  3097689.400057   616404.615091  3097694.993604
#Sta/Elev= 6
   0.000 640.384   0.200 640.384   0.200 632.472   5.400 632.472   5.400 640.384
   5.600 640.384
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1210.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616409.878181  3097689.638073   616409.609422  3097695.231620
#Sta/Elev= 6
   0.000 640.386   0.200 640.386   0.200 632.474   5.400 632.474   5.400 640.386
   5.600 640.386
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1215.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616414.869719  3097689.875959   616414.606547  3097695.469771
#Sta/Elev= 6
   0.000 640.389   0.200 640.389   0.200 632.477   5.400 632.477   5.400 640.389
   5.600 640.389
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1220.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616419.864052  3097690.113927   616419.600880  3097695.707740
#Sta/Elev= 6
   0.000 640.391   0.200 640.391   0.200 632.479   5.400 632.479   5.400 640.391
   5.600 640.391
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1225.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616424.858383  3097690.351943   616424.595211  3097695.945756
#Sta/Elev= 6
   0.000 640.394   0.200 640.394   0.200 632.482   5.400 632.482   5.400 640.394
   5.600 640.394
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1230.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616429.852714  3097690.589959   616429.589542  3097696.183771
#Sta/Elev= 6
   0.000 640.396   0.200 640.396   0.200 632.484   5.400 632.484   5.400 640.396
   5.600 640.396
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1235.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616434.849794  3097690.829054   616434.581035  3097696.422601
#Sta/Elev= 6
   0.000 640.399   0.200 640.399   0.200 632.487   5.400 632.487   5.400 640.399
   5.600 640.399
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1240.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616439.844125  3097691.067070   616439.575366  3097696.660617
#Sta/Elev= 6
   0.000 640.401   0.200 640.401   0.200 632.489   5.400 632.489   5.400 640.401
   5.600 640.401
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1245.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616444.838456  3097691.305086   616444.569697  3097696.898633
#Sta/Elev= 6
   0.000 640.404   0.200 640.404   0.200 632.492   5.400 632.492   5.400 640.404
   5.600 640.404
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1250.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616449.832789  3097691.543054   616449.564030  3097697.136601
#Sta/Elev= 6
   0.000 640.406   0.200 640.406   0.200 632.494   5.400 632.494   5.400 640.406
   5.600 640.406
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1255.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616454.827120  3097691.781070   616454.558361  3097697.374617
#Sta/Elev= 6
   0.000 640.409   0.200 640.409   0.200 632.497   5.400 632.497   5.400 640.409
   5.600 640.409
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1260.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616459.821451  3097692.019086   616459.552692  3097697.612633
#Sta/Elev= 6
   0.000 640.411   0.200 640.411   0.200 632.499   5.400 632.499   5.400 640.411
   5.600 640.411
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1265.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616464.815784  3097692.257054   616464.547025  3097697.850601
#Sta/Elev= 6
   0.000 640.414   0.200 640.414   0.200 632.502   5.400 632.502   5.400 640.414
   5.600 640.414
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1270.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616469.807322  3097692.494940   616469.544150  3097698.088753
#Sta/Elev= 6
   0.000 640.416   0.200 640.416   0.200 632.504   5.400 632.504   5.400 640.416
   5.600 640.416
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1275.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616474.801653  3097692.732956   616474.538481  3097698.326768
#Sta/Elev= 6
   0.000 640.419   0.200 640.419   0.200 632.507   5.400 632.507   5.400 640.419
   5.600 640.419
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1280.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616479.795986  3097692.970924   616479.532814  3097698.564737
#Sta/Elev= 6
   0.000 640.421   0.200 640.421   0.200 632.509   5.400 632.509   5.400 640.421
   5.600 640.421
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.400   0.015   0.000
Bank Sta=0.200,5.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1285.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616484.933388  3097693.011732   616484.377712  3097699.093637
#Sta/Elev= 6
   0.000 640.450   0.200 640.450   0.200 632.512   5.907 632.512   5.907 640.450
   6.107 640.450
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.907   0.015   0.000
Bank Sta=0.200,5.907
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1290.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616490.446371  3097694.567309   616488.552973  3097699.913042
#Sta/Elev= 6
   0.000 640.445   0.200 640.445   0.200 632.522   5.471 632.522   5.471 640.445
   5.671 640.445
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.471   0.015   0.000
Bank Sta=0.200,5.471
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1295.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616495.464116  3097697.257769   616492.333569  3097701.922677
#Sta/Elev= 6
   0.000 640.452   0.200 640.452   0.200 632.532   5.418 632.532   5.418 640.452
   5.618 640.452
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.418   0.015   0.000
Bank Sta=0.200,5.418
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1300.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616499.788443  3097700.978082   616495.371977  3097704.932153
#Sta/Elev= 6
   0.000 640.469   0.200 640.469   0.200 632.542   5.728 632.542   5.728 640.469
   5.928 640.469
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.728   0.015   0.000
Bank Sta=0.200,5.728
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1305.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616502.817926  3097705.384874   616498.227369  3097708.606121
#Sta/Elev= 6
   0.000 640.465   0.200 640.465   0.200 632.552   5.408 632.552   5.408 640.465
   5.608 640.465
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.408   0.015   0.000
Bank Sta=0.200,5.408
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1310.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616505.741839  3097709.441320   616501.047337  3097712.735506
#Sta/Elev= 6
   0.000 640.475   0.200 640.475   0.200 632.562   5.535 632.562   5.535 640.475
   5.735 640.475
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.535   0.015   0.000
Bank Sta=0.200,5.535
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1315.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616508.667648  3097713.495561   616503.866749  3097716.866155
#Sta/Elev= 6
   0.000 640.479   0.200 640.479   0.200 632.762   5.666 632.762   5.666 640.479
   5.866 640.479
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.666   0.015   0.000
Bank Sta=0.200,5.666
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1320.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616511.593604  3097717.550553   616506.684674  3097720.996994
#Sta/Elev= 6
   0.000 640.483   0.200 640.483   0.200 632.962   5.798 632.962   5.798 640.483
   5.998 640.483
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.798   0.015   0.000
Bank Sta=0.200,5.798
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1325.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616514.520468  3097721.605822   616509.502632  3097725.126895
#Sta/Elev= 6
   0.000 640.487   0.200 640.487   0.200 633.162   5.930 633.162   5.930 640.487
   6.130 640.487
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.930   0.015   0.000
Bank Sta=0.200,5.930
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1330.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616517.447057  3097725.662586   616512.319925  3097729.255961
#Sta/Elev= 6
   0.000 640.490   0.200 640.490   0.200 633.362   6.061 633.362   6.061 640.490
   6.261 640.490
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.061   0.015   0.000
Bank Sta=0.200,6.061
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1335.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616520.372205  3097729.715016   616515.139996  3097733.388422
#Sta/Elev= 6
   0.000 640.492   0.200 640.492   0.200 633.562   6.193 633.562   6.193 640.492
   6.393 640.492
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.193   0.015   0.000
Bank Sta=0.200,6.193
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1340.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616523.247537  3097733.806504   616518.009487  3097737.482104
#Sta/Elev= 6
   0.000 640.491   0.200 640.491   0.200 633.724   6.199 633.724   6.199 640.491
   6.399 640.491
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.199   0.015   0.000
Bank Sta=0.200,6.199
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1345.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616526.120532  3097737.900923   616520.880372  3097741.573514
#Sta/Elev= 6
   0.000 640.497   0.200 640.497   0.200 633.734   6.199 633.734   6.199 640.497
   6.399 640.497
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.199   0.015   0.000
Bank Sta=0.200,6.199
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1350.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616528.992048  3097741.990938   616523.754076  3097745.668390
#Sta/Elev= 6
   0.000 640.491   0.200 640.491   0.200 633.986   6.200 633.986   6.200 640.491
   6.400 640.491
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.200   0.015   0.000
Bank Sta=0.200,6.200
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1355.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616531.931393  3097745.929127   616526.601348  3097749.885176
#Sta/Elev= 6
   0.000 640.511   0.200 640.511   0.200 633.996   6.438 633.996   6.438 640.511
   6.638 640.511
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.438   0.015   0.000
Bank Sta=0.200,6.438
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1360.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616534.821789  3097748.944492   616530.778951  3097753.908483
#Sta/Elev= 6
   0.000 640.497   0.200 640.497   0.200 634.248   6.202 634.248   6.202 640.497
   6.402 640.497
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.202   0.015   0.000
Bank Sta=0.200,6.202
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1365.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616538.472293  3097750.978213   616535.719501  3097756.943692
#Sta/Elev= 6
   0.000 640.513   0.200 640.513   0.200 634.258   6.370 634.258   6.370 640.513
   6.570 640.513
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.370   0.015   0.000
Bank Sta=0.200,6.370
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1370.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616542.837994  3097752.600295   616540.777702  3097758.659602
#Sta/Elev= 6
   0.000 640.514   0.200 640.514   0.200 634.268   6.200 634.268   6.200 640.514
   6.400 640.514
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.200   0.015   0.000
Bank Sta=0.200,6.200
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1375.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616547.609096  3097754.100286   616545.476701  3097760.371645
#Sta/Elev= 6
   0.000 640.536   0.200 640.536   0.200 634.278   6.424 634.278   6.424 640.536
   6.624 640.536
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.424   0.015   0.000
Bank Sta=0.200,6.424
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1380.515,5.000,5.000,5.000
XS GIS Cut Line= 2
   616552.969431  3097753.851847   616549.586467  3097763.832119
#Sta/Elev= 6
   0.000 640.682   0.200 640.682   0.200 634.288  10.338 634.288  10.338 640.682
  10.538 640.682
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000  10.338   0.015   0.000
Bank Sta=0.200,10.338
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

River Reach=MTGHP           ,UsExit
Reach XY= 30
   616556.013000  3097760.448000   616555.543138  3097759.565260
   616555.543000  3097759.565000   616555.072862  3097758.682741
   616554.603000  3097757.800001   616554.133139  3097756.917261
   616554.133000  3097756.917000   616553.663277  3097756.034521
   616553.663000  3097756.034000   616553.193001  3097755.152001
   616553.193000  3097755.152000   616552.723139  3097754.269261
   616552.253277  3097753.386521   616552.253000  3097753.386000
   616551.783001  3097752.504002   616551.313139  3097751.621262
   616551.313000  3097751.621000   616550.843278  3097750.738522
   616550.843000  3097750.738000   616550.373001  3097749.856003
   616550.373000  3097749.856000   616549.903000  3097748.973000
   616549.433278  3097748.090522   616549.433000  3097748.090000
   616548.963002  3097747.208003   616548.963000  3097747.208000
   616548.493140  3097746.325263   616548.023278  3097745.442523
   616548.023000  3097745.442000   616547.904000  3097745.217000

Type RM Length L Ch R = 1 ,-0      ,,,
XS GIS Cut Line= 2
   616550.730081  3097743.722317   616545.077919  3097746.711683
#Sta/Elev= 6
   0.000 640.078   0.200 640.078   0.200 634.262   6.194 634.262   6.194 640.078
   6.394 640.078
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.194   0.015   0.000
Bank Sta=0.200,6.194
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7.255   ,7.255,7.255,7.255
XS GIS Cut Line= 2
   616554.236775  3097750.065080   616548.389504  3097753.177444
#Sta/Elev= 6
   0.000 640.085   0.200 640.085   0.200 634.278   6.424 634.278   6.424 640.085
   6.624 640.085
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.424   0.015   0.000
Bank Sta=0.200,6.424
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,12.255  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616558.314243  3097753.558922   616549.012311  3097758.510119
#Sta/Elev= 6
   0.000 640.089   0.200 640.089   0.200 634.288  10.338 634.288  10.338 640.089
  10.538 640.089
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000  10.338   0.015   0.000
Bank Sta=0.200,10.338
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

River Reach=MTGHP           ,forebay
Reach XY= 2
   616065.730000  3096621.868000   616065.730000  3096583.868000

Type RM Length L Ch R = 1 ,0       ,,,
XS GIS Cut Line= 2
   616068.432500  3096583.868000   616063.027500  3096583.868000
#Sta/Elev= 6
   0.000 624.028   0.200 624.028   0.200 621.978   5.205 621.978   5.205 624.028
   5.405 624.028
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.205   0.015   0.000
Bank Sta=0.200,5.205
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8       ,8.000,8.000,8.000
XS GIS Cut Line= 2
   616071.718000  3096591.868000   616059.742000  3096591.868000
#Sta/Elev= 6
   0.000 628.781   0.200 628.781   0.200 626.645  11.776 626.645  11.776 628.781
  11.976 628.781
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000  11.776   0.015   0.000
Bank Sta=0.200,11.776
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,13      ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616073.430000  3096596.868000   616058.030000  3096596.868000
#Sta/Elev= 6
   0.000 631.093   0.200 631.093   0.200 628.978  15.200 628.978  15.200 631.093
  15.400 631.093
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000  15.200   0.015   0.000
Bank Sta=0.200,15.200
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,18      ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616073.430000  3096601.868000   616058.030000  3096601.868000
#Sta/Elev= 6
   0.000 631.093   0.200 631.093   0.200 628.978  15.200 628.978  15.200 631.093
  15.400 631.093
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000  15.200   0.015   0.000
Bank Sta=0.200,15.200
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,23      ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616073.430000  3096606.868000   616058.030000  3096606.868000
#Sta/Elev= 6
   0.000 631.093   0.200 631.093   0.200 628.978  15.200 628.978  15.200 631.093
  15.400 631.093
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000  15.200   0.015   0.000
Bank Sta=0.200,15.200
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,28      ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616072.641000  3096611.868000   616058.819000  3096611.868000
#Sta/Elev= 6
   0.000 631.770   0.200 631.770   0.200 629.647  13.622 629.647  13.622 631.770
  13.822 631.770
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000  13.622   0.015   0.000
Bank Sta=0.200,13.622
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,33      ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616075.430000  3096616.868000   616056.030000  3096616.868000
#Sta/Elev= 6
   0.000 632.859   0.200 632.859   0.200 630.761  19.200 630.761  19.200 632.859
  19.400 632.859
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000  19.200   0.015   0.000
Bank Sta=0.200,19.200
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

River Reach=MTGHP           ,sidechannel
Reach XY= 30
   616065.730000  3096621.868000   616066.682000  3096621.562000
   616067.635000  3096621.257000   616068.586470  3096620.951170
   616069.538789  3096620.646068   616070.491000  3096620.340000
   616073.348000  3096619.424000   616074.300000  3096619.118000
   616075.252000  3096618.813000   616076.070000  3096618.342000
   616076.561000  3096617.471000   616077.545000  3096615.730000
   616078.036000  3096614.859000   616078.528000  3096613.988000
   616080.002000  3096611.375000   616080.494000  3096610.505000
   616080.985000  3096609.634000   616081.408000  3096608.742000
   616081.483000  3096607.745000   616081.557000  3096606.748000
   616081.632000  3096605.750000   616081.780000  3096603.756000
   616081.855000  3096602.759000   616081.929000  3096601.762000
   616082.004000  3096600.764000   616082.078000  3096599.767000
   616082.153000  3096598.770000   616082.227000  3096597.773000
   616082.302000  3096596.775000   616082.376000  3096595.778000

Type RM Length L Ch R = 1 ,-0      ,,,
XS GIS Cut Line= 2
   616084.480212  3096595.934180   616080.271788  3096595.621820
#Sta/Elev= 6
   0.000 636.064   0.200 636.064   0.200 631.500   4.020 631.500   4.020 636.064
   4.220 636.064
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.020   0.015   0.000
Bank Sta=0.200,4.020
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4.931   ,4.931,4.931,4.931
XS GIS Cut Line= 2
   616084.381824  3096600.871057   616079.636426  3096600.518841
#Sta/Elev= 6
   0.000 636.721   0.200 636.721   0.200 631.500   4.558 631.500   4.558 636.721
   4.758 636.721
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.558   0.015   0.000
Bank Sta=0.200,4.558
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9.931   ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616084.282038  3096605.877403   616078.992192  3096605.484777
#Sta/Elev= 6
   0.000 636.934   0.200 636.934   0.200 631.500   5.104 631.500   5.104 636.934
   5.304 636.934
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.104   0.015   0.000
Bank Sta=0.200,5.104
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,14.931  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616082.846788  3096611.766398   616078.196750  3096609.145080
#Sta/Elev= 6
   0.000 637.007   0.200 637.007   0.200 631.500   5.138 631.500   5.138 637.007
   5.338 637.007
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.138   0.015   0.000
Bank Sta=0.200,5.138
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,19.931  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616080.434999  3096616.149275   616075.692536  3096613.470410
#Sta/Elev= 6
   0.000 637.057   0.200 637.057   0.200 631.500   5.247 631.500   5.247 637.057
   5.447 637.057
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.247   0.015   0.000
Bank Sta=0.200,5.247
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,24.931  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616076.287898  3096622.046611   616074.215956  3096615.579435
#Sta/Elev= 6
   0.000 637.254   0.200 637.254   0.200 631.500   6.591 631.500   6.591 637.254
   6.791 637.254
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.591   0.015   0.000
Bank Sta=0.200,6.591
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,29.931  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616073.153069  3096628.622616   616067.828567  3096612.057501
#Sta/Elev= 6
   0.000 637.480   0.200 637.480   0.200 631.500  17.200 631.500  17.200 637.480
  17.400 637.480
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000  17.200   0.015   0.000
Bank Sta=0.200,17.200
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

River Reach=MTGHP           ,drain
Reach XY= 30
   616073.135000  3096615.242000   616073.977046  3096613.427900
   616074.399000  3096612.521000   616075.240938  3096610.707133
   616075.663000  3096609.800000   616075.995000  3096608.872000
   616076.032000  3096607.872000   616076.108000  3096605.874000
   616076.145000  3096604.875000   616076.221000  3096602.876000
   616076.258000  3096601.877000   616076.334000  3096599.878000
   616076.371000  3096598.879000   616076.447000  3096596.880000
   616076.484000  3096595.881000   616076.362000  3096594.923000
   616073.750000  3096590.660000   616073.228000  3096589.807000
   616072.705000  3096588.955000   616072.188000  3096588.099000
   616071.764000  3096587.193000   616070.918000  3096585.381000
   616070.742000  3096584.409000   616070.654000  3096583.413000
   616070.647000  3096582.413000   616070.629000  3096579.413000
   616070.622000  3096578.413000   616070.604000  3096575.413000
   616070.597000  3096574.413000   616070.582000  3096571.989000

Type RM Length L Ch R = 1 ,0       ,,,
XS GIS Cut Line= 2
   616072.381955  3096571.976264   616068.782045  3096572.001736
#Sta/Elev= 6
   0.000 627.000   0.200 627.000   0.200 622.000   3.400 622.000   3.400 627.000
   3.600 627.000
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   3.400   0.015   0.000
Bank Sta=0.200,3.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,5.363   ,5.363,5.363,5.363
XS GIS Cut Line= 2
   616072.415603  3096577.341478   616068.815668  3096577.363077
#Sta/Elev= 6
   0.000 629.210   0.200 629.210   0.200 624.257   3.400 624.257   3.400 629.210
   3.600 629.210
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   3.400   0.015   0.000
Bank Sta=0.200,3.400
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10.363  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616072.562120  3096582.340688   616068.731150  3096582.363674
#Sta/Elev= 6
   0.000 630.975   0.200 630.975   0.200 626.157   3.631 626.157   3.631 630.975
   3.831 630.975
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   3.631   0.015   0.000
Bank Sta=0.200,3.631
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,15.363  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616073.706206  3096586.232909   616069.780932  3096588.065570
#Sta/Elev= 6
   0.000 632.635   0.200 632.635   0.200 628.062   4.132 628.062   4.132 632.635
   4.332 632.635
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.132   0.015   0.000
Bank Sta=0.200,4.132
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,20.363  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616076.277365  3096590.226650   616072.217467  3096592.715896
#Sta/Elev= 6
   0.000 634.988   0.200 634.988   0.200 629.961   4.562 629.961   4.562 634.988
   4.762 634.988
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   4.562   0.015   0.000
Bank Sta=0.200,4.562
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,25.363  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616079.614915  3096595.468487   616073.349628  3096596.266362
#Sta/Elev= 6
   0.000 634.992   0.200 634.992   0.200 631.500   6.116 631.500   6.116 634.992
   6.316 634.992
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   6.116   0.015   0.000
Bank Sta=0.200,6.116
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,30.363  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616079.180145  3096600.973476   616073.412861  3096600.754100
#Sta/Elev= 6
   0.000 634.992   0.200 634.992   0.200 631.500   5.571 631.500   5.571 634.992
   5.771 634.992
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.571   0.015   0.000
Bank Sta=0.200,5.571
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,35.363  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616078.719969  3096605.956973   616073.497050  3096605.763531
#Sta/Elev= 6
   0.000 634.992   0.200 634.992   0.200 631.500   5.027 631.500   5.027 634.992
   5.227 634.992
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   5.027   0.015   0.000
Bank Sta=0.200,5.027
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,40.363  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616076.991979  3096611.519909   616073.489897  3096609.894356
#Sta/Elev= 6
   0.000 634.992   0.200 634.992   0.200 631.500   3.661 631.500   3.661 634.992
   3.861 634.992
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   3.661   0.015   0.000
Bank Sta=0.200,3.661
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,45.363  ,5.000,5.000,5.000
XS GIS Cut Line= 2
   616074.246136  3096615.757753   616072.023864  3096614.726247
#Sta/Elev= 6
   0.000 634.992   0.200 634.992   0.200 631.500   2.250 631.500   2.250 634.992
   2.450 634.992
#Mann= 3 ,0,0
   0.000   0.015   0.000   0.200   0.015   0.000   2.250   0.015   0.000
Bank Sta=0.200,2.250
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
